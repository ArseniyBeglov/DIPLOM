# Keil uVision project lab1.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lab1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c delay.h delay.c lcd.c lcd.h uart.c uart.h adc.c adc.h dac.c dac.h pwm.c pwm.h font5x8.h graphic.c graphic.h KS0108.c KS0108.h KS0108-STM32.c button.h button.c timeout.c timeout.h measurement.c measurement.h storage.h storage.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, Device:STM32Cube HAL:ADC 1.11.3, Device:STM32Cube HAL:COMMON 1.11.3, Device:STM32Cube HAL:CORTEX 1.11.3, Device:STM32Cube HAL:DAC 1.11.3, Device:STM32Cube HAL:DMA 1.11.3, Device:STM32Cube HAL:FLASH 1.11.3, Device:STM32Cube HAL:GPIO 1.11.3, Device:STM32Cube HAL:PCD 1.11.3, Device:STM32Cube HAL:PWR 1.11.3, Device:STM32Cube HAL:RCC 1.11.3, Device:STM32Cube HAL:RTC 1.11.3, Device:STM32Cube HAL:TIM 1.11.3, Device:STM32Cube HAL:UART 1.11.3, Device:STM32Cube HAL:USART 1.11.3, Device:Startup 1.0.0
